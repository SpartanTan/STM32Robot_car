# Keil uVision project PWM.uvprojx, settings and files
target 越野 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 越野
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\STM32F10x_FWLib\inc;..\..\pwm;..\HARDWARE\EXTI;..\HARDWARE\REMOTE;..\HARDWARE\xunji;..\HARDWARE\xunji;..\HARDWARE\Init;..\HARDWARE\chuanganqi;..\HARDWARE\yanse;..\HARDWARE\duoji;..\HARDWARE\fenduan;..\HARDWARE\movements;..\HARDWARE\ceju;..\HARDWARE\adc2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c bin.txt
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/xunji/: xunji.c
    ../HARDWARE/Init/: Init.c
    ../HARDWARE/duoji/: duoj.c
    ../HARDWARE/yanse/: rgb3.c
    ../HARDWARE/fenduan/: fenduan.c
    ../HARDWARE/movements/: movements.c
    ../HARDWARE/ceju/: ceju.c
    ../HARDWARE/adc2/: adc2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c
